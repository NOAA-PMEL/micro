# IAR project LoadCell.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR5949 MSP430FR5949
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr5949.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group inc
    inc/: includes.h
  group src
    src/: main.c
  group src/buffer
    src/buffer/: buffer16.c buffer16.h buffer32.c buffer32.h buffer8.c buffer8.h buffer_c.c buffer_c.h buffer_d.c buffer_d.h buffer_f.c buffer_f.h buffers.h
  group src/console
    src/console/: console.c console.h
  group src/gpio
    src/gpio/: gpio.c gpio.h
  group src/Hardware
    src/Hardware/: lowlevel.c lowlevel.h
  group src/I2C
    src/I2C/: i2c.c i2c.h
  group src/Keller
    src/Keller/: PAxLD.c PAxLD.h
    src/UART/: uart.c uart.h
  group Test
    test/: msp430fr5969.h test_buffer16.c test_buffer32.c test_buffer8.c test_buffer_c.c test_buffer_d.c test_buffer_f.c test_buffers.c test_console.c test_gpio.c test_i2c.c test_lowlevel.c test_PAxLD.c test_uart.c
