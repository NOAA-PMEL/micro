# IAR project RadiationSensor_V40.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group (top)
    ./: main.c
  group buffers
    src/buffers/: buffer16.c buffer16.h buffer8.c buffer8.h buffer_c.c buffer_c.h buffer_f.c buffer_f.h
  group Console
    src/Console/: console.c console.h
  group GPIO
    src/GPIO/: gpio.c gpio.h
  group MAX1247
    src/MAX1247/: MAX1247.c MAX1247.h
  group rtc
    src/rtc/: rtc.c rtc.h
  group SPI
    src/SPI/: spi.c spi.h
  group Stats
    src/Stats/: statistics.c statistics.h
  group Timer
    src/Timer/: timer.c timer.h
  group UART
    src/UART/: uart.c uart.h
