# IAR project RainGauge_v4_1_0.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR5949 MSP430FR5949
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: PMEL
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr5949.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group inc
    inc/: includes.h
  group src
    ./: main.c
  group src/buffers
    src/buffers/: buffer16.c buffer16.h buffer8.c buffer8.h buffer_c.c buffer_c.h buffer_f.c buffer_f.h
  group src/Console
    src/Console/: console.c console.h
  group src/GPIO
    src/GPIO/: gpio.c gpio.h
  group src/rtc
    src/rtc/: rtc.c rtc.h
  group src/Stats
    src/Stats/: statistics.c statistics.h
  group src/Timer
    src/Timer/: timer.c timer.h
  group src/UART
    src/UART/: uart.c uart.h
