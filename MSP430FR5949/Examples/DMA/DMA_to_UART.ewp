# IAR project DMA_to_UART.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR5949 MSP430FR5949
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: PMEL
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr5949.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.c
  group inc
    inc/: includes.h
  group src/DMA
    src/DMA/: dma.c dma.h
  group src/GPIO
    src/GPIO/: gpio.c gpio.h
  group src/RTC
    src/rtc/: rtc.c rtc.h
  group src/Timer
    src/Timer/: timer.c timer.h
  group src/UART
    src/UART/: uart.c uart.h
